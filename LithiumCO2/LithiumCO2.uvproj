# Keil uVision project LithiumCO2.uvproj, settings and files
target Example-ERP2 (MCS-51)
  device: R8051XC2 (2 DPTR) Evatronix
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MODC2 MDU_R515
  output: LithiumCO2 +hex
  AfterMake: eopx2.exe -fprg "#H" -fcfg "$H@H_cfg.hex" -script "$Ppostbuild.txt"
  c flags: Optimize=9 SizeSpeed=1
  c define: RELEASE
  group Application
    ./: EO3100I_CFG.h EO3100I_CFG.c main.c STARTUP.A51 postbuild.txt LRNtelegram.c ram0.c DolphinSTM.h LRNtelegram.h main.h ram0.h
  group EO3100I_API
    ../../EO3100I_LIB/: EO3100I_API-ERP2.LIB EO3100I_API.h
